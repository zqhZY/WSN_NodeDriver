# IAR project CMacDevV1.0.ewp, settings and files
configuration Debug (STM8, debug)
  General.GenDeviceSelectMenu: UnspecifiedSTM8 STM8 - Unspecified
  General.GenCodeModel: 0
  General.GenDataModel: 1
  ICCSTM8.IccLang: 0
  ILINK.IlinkOutputFile: CMacDevV1.0.out
  ILINK.IlinkStackSize: 1
  ILINK.IlinkHeapSize: 1
configuration Release (STM8)
  as the first configuration, except:
  General.GenDeviceSelectMenu: STM8L151K4 STM8L151K4
  General.GenCodeModel: 1
  General.GenStackSize: 0x100
  General.GenHeapSize: 0x100
  ICCSTM8.CCDefines: STM8L15X_MD
  ICCSTM8.CCIncludePath2: Library\STM8L15x_StdPeriph_Driver\inc; Library\STM8L15x_StdPeriph_Driver\src; USER; Utilities\STM8_EVAL; Utilities\STM8_EVAL\STM8L1526_EVAL
  OBJCOPY.OOCOutputFile: CMacDevV1.0.srec
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group (top)
    ./: main.c
  group StdLib
    Library/STM8L15x_StdPeriph_Driver/src/: stm8l15x_adc.c stm8l15x_clk.c stm8l15x_dma.c stm8l15x_exti.c stm8l15x_gpio.c stm8l15x_itc.c stm8l15x_rst.c stm8l15x_rtc.c stm8l15x_spi.c stm8l15x_syscfg.c stm8l15x_tim1.c stm8l15x_tim2.c stm8l15x_tim3.c stm8l15x_tim4.c stm8l15x_tim5.c stm8l15x_usart.c stm8l15x_wwdg.c
  group USER
    USER/: MyDelay.c MyExitInt.c MyGpio.c Myhalt.c MySpi.c MyUart.c Sensor.c Si4432.c stm8l15x_it.c
